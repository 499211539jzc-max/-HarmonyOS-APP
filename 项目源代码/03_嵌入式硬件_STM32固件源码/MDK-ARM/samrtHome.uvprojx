# Keil uVision project samrtHome.uvprojx, settings and files
target samrtHome (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431VCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: samrtHome +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Balcony;..\Bedroom;..\Kitchen;..\Toilet;..\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Toilet
    ../Toilet/: toilet_led.c toilet_led.h toilet_sensor.c toilet_sensor.h toilet_monitor.c toilet_monitor.h
  group Bedroom
    ../Bedroom/: bedroom_led.c bedroom_led.h bedroom_eth30.c bedroom_eth30.h bedroom_monitor.c bedroom_monitor.h
  group Kitchen
    ../Kitchen/: kitchen_beep.c kitchen_beep.h kitchen_fan.c kitchen_fan.h kitchen_gas.c kitchen_gas.h kitchen_monitor.c kitchen_monitor.h
  group Utils
    ../Utils/: esp8285.c esp8285.h mqtt.c mqtt.h
software components: CMSIS:CORE 4.3.0
